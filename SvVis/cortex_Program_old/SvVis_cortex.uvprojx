# Keil uVision project SvVis_cortex.uvprojx, settings and files
target ARM_Minalsystem (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F107RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTX5_Delay
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: SvVis_cortex.cpp main.cpp SvVis_cortex_threads.cpp LED_driver.c USART_driver.cpp WLAN_driver.cpp motor_driver.cpp ring_pipe.cpp extra.cpp
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS2:Keil RTX5 5.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
